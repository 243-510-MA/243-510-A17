<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>run_MUSIC_lin_array_X310_TwinRX</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>input_variables</value></param>
<param><key>value2</key><value>2450000000</value></param>
<param><key>comment</key><value>input_variables: 
Contains all the user-defined variables.</value></param>
<param><key>value11</key><value>"/tmp"</value></param>
<param><key>field0</key><value>ToneFreq</value></param>
<param><key>field1</key><value>SampleRate</value></param>
<param><key>field10</key><value>PSpectrumLength</value></param>
<param><key>field11</key><value>DirectoryConfigFiles</value></param>
<param><key>field12</key><value>RelativePhaseOffsets</value></param>
<param><key>field2</key><value>CenterFreq</value></param>
<param><key>field3</key><value>RxAddr</value></param>
<param><key>field4</key><value>Gain</value></param>
<param><key>field5</key><value>NumArrayElements</value></param>
<param><key>field6</key><value>NormSpacing</value></param>
<param><key>field7</key><value>SnapshotSize</value></param>
<param><key>field8</key><value>OverlapSize</value></param>
<param><key>field9</key><value>NumTargets</value></param>
<param><key>value4</key><value>60</value></param>
<param><key>value6</key><value>0.5</value></param>
<param><key>value5</key><value>4</value></param>
<param><key>value9</key><value>1</value></param>
<param><key>value8</key><value>2**9</value></param>
<param><key>value10</key><value>2**10</value></param>
<param><key>value12</key><value>"measure_X310_TwinRX_relative_phase_offsets_245.cfg"</value></param>
<param><key>value3</key><value>"addr=192.168.40.2"</value></param>
<param><key>value1</key><value>1e6</value></param>
<param><key>value7</key><value>2**11</value></param>
<param><key>value0</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rel_phase_offsets_file_name</value></param>
<param><key>value</key><value>os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>input_variables.NumTargets</value></param>
</block>
<block>
<key>doa_MUSIC_lin_array</key>
<param><key>id</key><value>doa_MUSIC_lin_array_0</value></param>
<param><key>norm_spacing</key><value>input_variables.NormSpacing</value></param>
<param><key>inputs</key><value>input_variables.NumArrayElements</value></param>
<param><key>num_targets</key><value>input_variables.NumTargets</value></param>
<param><key>pspectrum_len</key><value>input_variables.PSpectrumLength</value></param>
</block>
<block>
<key>doa_autocorrelate</key>
<param><key>id</key><value>doa_autocorrelate_0</value></param>
<param><key>avg_method</key><value>1</value></param>
<param><key>inputs</key><value>input_variables.NumArrayElements</value></param>
<param><key>overlap_size</key><value>input_variables.OverlapSize</value></param>
<param><key>snapshot_size</key><value>input_variables.SnapshotSize</value></param>
</block>
<block>
<key>doa_qt_compass</key>
<param><key>id</key><value>doa_compass</value></param>
<param><key>arc_bias</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>max_val</key><value>180</value></param>
<param><key>min_val</key><value>0</value></param>
<param><key>name</key><value>""</value></param>
<param><key>step</key><value>10</value></param>
<param><key>update_time</key><value>0.05</value></param>
</block>
<block>
<key>doa_find_local_max</key>
<param><key>id</key><value>doa_find_local_max_0</value></param>
<param><key>num_max_vals</key><value>input_variables.NumTargets</value></param>
<param><key>vector_len</key><value>input_variables.PSpectrumLength</value></param>
<param><key>x_max</key><value>180.0</value></param>
<param><key>x_min</key><value>0.0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import</value></param>
<param><key>import</key><value>import os</value></param>
</block>
<block>
<key>phase_correct_hier</key>
<param><key>id</key><value>phase_correct_hier_1</value></param>
<param><key>config_filename</key><value>/home/gnuradio/Desktop/Correction/correction_3</value></param>
<param><key>num_ports</key><value>input_variables.NumArrayElements</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>color5</key><value>"cyan"</value></param>
<param><key>label5</key><value></value></param>
<param><key>color6</key><value>"magenta"</value></param>
<param><key>label6</key><value></value></param>
<param><key>color7</key><value>"yellow"</value></param>
<param><key>label7</key><value></value></param>
<param><key>color8</key><value>"dark red"</value></param>
<param><key>label8</key><value></value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>width1</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>0.05</value></param>
<param><key>vlen</key><value>input_variables.PSpectrumLength</value></param>
<param><key>x_axis_label</key><value>"angle (in degrees)"</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>180.0/input_variables.PSpectrumLength</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-20</value></param>
<param><key>y_axis_label</key><value>"Pseudo-Spectrum (dB)"</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>Pseudo-Spectrum</value></param>
<param><key>label1</key><value>Angle of Arrival (MUSIC)</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>2.4e9</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>ant1</key><value>RX2</value></param>
<param><key>center_freq1</key><value>2.4e9</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>20</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr0=192.168.10.2,addr1=192.168.10.3"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>mimo</value></param>
<param><key>time_source0</key><value>mimo</value></param>
<param><key>clock_source1</key><value>external</value></param>
<param><key>time_source1</key><value>external</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>num_mboards</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>2.4e9</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>ant1</key><value>RX2</value></param>
<param><key>center_freq1</key><value>2.4e9</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>20</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr0=192.168.20.2,addr1=192.168.20.3"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>gpsdo</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>clock_source1</key><value>mimo</value></param>
<param><key>time_source1</key><value>mimo</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>num_mboards</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_1</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_2</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>doa_MUSIC_lin_array_0</source_block_id><sink_block_id>doa_find_local_max_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_MUSIC_lin_array_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_autocorrelate_0</source_block_id><sink_block_id>doa_MUSIC_lin_array_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_find_local_max_0</source_block_id><sink_block_id>doa_compass</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_find_local_max_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
