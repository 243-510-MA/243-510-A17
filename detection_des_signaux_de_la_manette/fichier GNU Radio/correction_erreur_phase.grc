<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>estimate_X310_TwinRX_constant_phase_offsets_and_save</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>input_variables</value></param>
<param><key>value2</key><value>2450000000</value></param>
<param><key>comment</key><value>input_variables: 
Contains all the user-defined variables.</value></param>
<param><key>value6</key><value>"/tmp"</value></param>
<param><key>field0</key><value>SampleRate</value></param>
<param><key>field1</key><value>ToneFreq</value></param>
<param><key>field2</key><value>CenterFreq</value></param>
<param><key>field3</key><value>Gain</value></param>
<param><key>field4</key><value>NumArrayElements</value></param>
<param><key>field5</key><value>RxAddr</value></param>
<param><key>field6</key><value>DirectoryConfigFiles</value></param>
<param><key>field7</key><value>RelativePhaseOffsets</value></param>
<param><key>field8</key><value>SkipAhead</value></param>
<param><key>field9</key><value>Samples2FindMax</value></param>
<param><key>value3</key><value>60</value></param>
<param><key>value4</key><value>4</value></param>
<param><key>value7</key><value>"measure_X310_TwinRX_relative_phase_offsets_245.cfg"</value></param>
<param><key>value5</key><value>"addr=192.168.10.2"</value></param>
<param><key>value0</key><value>10e6</value></param>
<param><key>value9</key><value>2**11</value></param>
<param><key>value8</key><value>2**13</value></param>
<param><key>value1</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rel_phase_offsets_file_name</value></param>
<param><key>value</key><value>os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>doa_findmax_and_save</key>
<param><key>id</key><value>doa_findmax_and_save_0</value></param>
<param><key>config_filename</key><value>/home/gnuradio/Desktop/Correction/correction_3</value></param>
<param><key>num_inputs</key><value>input_variables.NumArrayElements-1</value></param>
<param><key>samples_to_findmax</key><value>input_variables.Samples2FindMax</value></param>
</block>
<block>
<key>doa_twinrx_phase_offset_est</key>
<param><key>id</key><value>doa_twinrx_phase_offset_est_0</value></param>
<param><key>num_inputs</key><value>input_variables.NumArrayElements</value></param>
<param><key>n_skip_ahead</key><value>input_variables.SkipAhead</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import</value></param>
<param><key>import</key><value>import os</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>2.4e9</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant1</key><value>RX2</value></param>
<param><key>center_freq1</key><value>2.4e9</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr0=192.168.10.2,addr1=192.168.10.3"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>mimo</value></param>
<param><key>time_source0</key><value>mimo</value></param>
<param><key>clock_source1</key><value>external</value></param>
<param><key>time_source1</key><value>external</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>num_mboards</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>2.4e9</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant1</key><value>RX2</value></param>
<param><key>center_freq1</key><value>2.4e9</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr0=192.168.20.2,addr1=192.168.20.3"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>gpsdo</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>clock_source1</key><value>mimo</value></param>
<param><key>time_source1</key><value>mimo</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>num_mboards</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>doa_twinrx_phase_offset_est_0</source_block_id><sink_block_id>doa_findmax_and_save_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_twinrx_phase_offset_est_0</source_block_id><sink_block_id>doa_findmax_and_save_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>doa_twinrx_phase_offset_est_0</source_block_id><sink_block_id>doa_findmax_and_save_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>doa_twinrx_phase_offset_est_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>doa_twinrx_phase_offset_est_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_0</source_block_id><sink_block_id>doa_twinrx_phase_offset_est_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_0</source_block_id><sink_block_id>doa_twinrx_phase_offset_est_0</sink_block_id><source_key>1</source_key><sink_key>3</sink_key></connection>
</flow_graph>
